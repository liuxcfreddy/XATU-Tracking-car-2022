# Keil uVision project 寻迹车2022.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: 循迹车_2022 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Library
  group Source Group 1
    ./: main.c
  group library
    ./Library/: STARTUP.A51 STC89C5xRC.h
